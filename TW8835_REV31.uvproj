# Keil uVision project TW8835_REV31.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS80C320 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: TW8835_REV31 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: EVB_30 EVB_31 nullFn="//"
  link misc: RECURSIONS (30)
BANK0(?CO?MAIN, ?CO?HOST, ?CO?SPI, ?CO?Decoder, ?CO?VAdc, ?CO?MEASURE, ?CO?Scaler, ?CO?INPUTCTRL, ?CO?IMAGECTRL, ?CO?OutputCtrl, ?CO?SETTINGS, ?CO?eeprom, ?CO?TouchKey, ?CO?HID, ?CO?PC_modes, ?CO?DTV, ?CO?HDMI_EP9351)
BANK1(?CO?MONITOR, ?CO?MONITOR_MCU, ?CO?MONITOR_SPI, ?CO?MONITOR_MENU, ?CO?DebugMsg)
BANK2(?CO?SOsdMenu, ?CO?SpiFlashMap, ?CO?SOsdMenuMap, ?CO?OSDFONT, ?CO?OSDSPI, ?CO?FOsdString, ?CO?FOsdTable, ?CO?FOsdDisplay, ?CO?FOsdMenu)
BANK3(?CO?DemoMain, ?CO?Test_FOSD)
  group Source Group 1
    ./: CPU.c Util.c Printf.c Release.txt L51_BANK.A51
  group Bank0
    ./: main.c Host.c SPI.c i2c.c Decoder.c VADC.c measure.c Scaler.c InputCtrl.c ImageCtrl.c OutputCtrl.c Settings.c EEPROM.c Remo.c TouchKey.c HID.c DTV.c PC_modes.c HDMI_EP9351.c HDMI_SIL9127.c misc.c
  group Bank1
    ./: monitor.c Monitor_MCU.c monitor_SPI.c monitor_menu.c DebugMsg.c
  group Bank2
    ./: OSDFont.c OSDSPI.c FOsdString.c FOsdTable.c FOsdDisplay.c FOsdMenu.c SpiFlashMap.c SOsdMenuMap.c SOsdMenu.c
  group Bank3
    ./: DemoMain.c test_FOSD.c junk.c
